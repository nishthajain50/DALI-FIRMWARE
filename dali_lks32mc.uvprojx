# Keil uVision project dali_lks32mc.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: LKS32MC033H6P8 Linko
  pack: Linko.LKS03x.1.1.8
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: dali_lks32mc +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Source Group 1
    ./: hardware.h dali_machine.h dali_machine.c dali_protocol.h dali_protocol.c led_dimmer.h led_dimmer.c memory.h memory.c
    ../../../../lks2/: main.c
    ../../../../LKS/: startup_lks32mc03x.s
software components: CMSIS:CORE 6.2.0
